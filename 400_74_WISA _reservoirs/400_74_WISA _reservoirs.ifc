Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2015-03-31T09:55:45
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20140709_2115(x64) - Exporter 2014.0.2014.0709 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 31 09:55:45 2015 * Host: PC-ARN-001 * Database: C:\Users\mdegans\AppData\Local\Temp\{EACEC74F-EC55-438A-A2B1-77A39998B894}\ifc * Database version: 5507 * Database creation date: Tue Mar 31 09:55:43 2015 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Mar 31 09:55:43 2015 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 31 09:55:43 2015 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: R:\Revit 2014\02-Te controleren\Bibliotheken\Engels\IFC\400_74_WISA _reservoirs.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Graphics - Line Pattern: -3000010; Color: 0; Symbol at End 2 Default: yes; Line Weight: 1; Symbol at End 1 Default: no
Dimensions - Computation Height: 0 mm
Identity Data - Name: Level 1; Structural: no; Building Story: yes

# IfcBuildingElementProxy: Model Text:Model Text 1
In: Level 1
Identity Data - Subcategory: -2000151
Phasing - Phase Created: New Construction
Graphics - Text: CISTERNS; Horizontal Align: Left
Materials and Finishes - Material: WISA zwart
Dimensions - Depth: 50 mm
Constraints - Work Plane: Level : Level 1
Pset_BuildingElementProxyCommon - Reference: Model Text 1
Text - Bold: no; Text Font: Arial; Text Size: 600 mm; Italic: no

# IfcBuildingElementProxy: Model Text:Model Text 2 (2)
In: Level 1
Constraints - Work Plane: Level : Level 1
Graphics - Horizontal Align: Left
Identity Data - Subcategory: -2000151
Dimensions - Depth: 50 mm
Phasing - Phase Created: New Construction
Materials and Finishes - Material: WISA zwart
Pset_BuildingElementProxyCommon - Reference: Model Text 2
Text - Text Size: 400 mm; Text Font: Arial; Bold: no; Italic: no
Name (Model Text:...) | Text
Model Text 2 | LOW HANGING
Model Text 2 | HIGH HANGING AND CLOSE COUPLED

# IfcBuildingElementProxy: Model Text:Model Text 3 (10)
In: Level 1
Phasing - Phase Created: New Construction
Graphics - Horizontal Align: Left
Materials and Finishes - Material: WISA zwart
Identity Data - Subcategory: -2000151
Constraints - Work Plane: Level : Level 1
Dimensions - Depth: 50 mm
Pset_BuildingElementProxyCommon - Reference: Model Text 3
Text - Italic: no; Text Size: 200 mm; Bold: no; Text Font: Arial
Name (Model Text:...) | Text
Model Text 3 | WISA 336
Model Text 3 | WISA 300
Model Text 3 | WISA 1000
Model Text 3 | WISA 500
Model Text 3 | WISA 900
Model Text 3 | WISA 790
Model Text 3 | WISA 800
Model Text 3 | WISA 285
Model Text 3 | WISA 444
Model Text 3 | WISA 1036

# IfcFlowTerminal: pergamon_wisa_cistern wisa 1000, RSen_74_PF_FB_surface mounted flushing reservoir wisa 1000_wisa:pergamon_wisa_cistern wisa 1000:3785867
In: Level 1
Type - ElementType: pergamon_wisa_cistern wisa 1000; PredefinedType: CISTERN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_n6_PEXa_pergamon
Plumbing - cw_position: 3; cw_connection_right: no; cw_connection_left: yes; cw_connection_behind: no
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_pergamon
General - Rsen_C_content_creator: WISA
Mechanical - Rsen_P_c01_fixture units: 0; CWFU: 0; WFU: 0; System Classification: Domestic Cold Water
Other - country_index: 1; Schedule Level: Level: Level 1; calc_connection-depth: 240 mm; cw_length: 226.5 mm; cw_angle: 180 deg; cw_height: 331 mm
Text - Rsen_P_c01_definition: c01_cw; water connection: G 3/8
Dimensions - Rsen_P_c01_diameter: 10 mm; Rsen_C_width: 453 mm; Rsen_C_height: 431 mm; connection-height: 365 mm; Rsen_C_depth: 130 mm; connection-depth: 245 mm; flush pipe_height: 182 mm
Constraints - Default Elevation: 0 mm; Host: Reference Plane; Elevation: 0 mm
Mechanical - Flow - flush_volume: 0.317832 ft3
Identity Data - Manufacturer: WISA; Description: WISA 1000 pergamon; Rsen_C_code_gtin: 8711778032729; Type Comments: Low hanging cisterns; Rsen_C_code_ETIM: EC010864; Rsen_C_code_SfB_table1: 74.10; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010864&ArtClassVersion=3; Assembly Code: 4A(74.22); Assembly Description: ingebouwde sanitaire voorzieningen; URL: www.wisa-sanitair.com/nl/8050424007; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_code_STABU: 53.31; Rsen_C_code_manufacturer_product: 8050424007; Rsen_C_model: 1000; Rsen_C_type_comments: Laaghangend reservoir; Model: 1000; Rsen_C_description: WISA 1000 pergamon; NLRS_C_revit_versie: 2014; Mark: 1716
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: pergamon_wisa_cistern wisa 1036, RSen_74_PF_FB_surface mounted flushing reservoir wisa 1036_wisa:pergamon_wisa_cistern wisa 1036:3786011
In: Level 1
Type - ElementType: pergamon_wisa_cistern wisa 1036; PredefinedType: CISTERN; Classification: 4A(74.10) algemeen (verzamelniveau) (UniFormat); Material: RSen_n6_PEXa_pergamon
Other - country_index: 1; Schedule Level: Level: Level 1; cw_length: 226.5 mm; cw_angle: 180 deg; cw_height: 331 mm; calc_connection-depth: 240 mm
Mechanical - Rsen_P_c01_fixture units: 0; CWFU: 0; WFU: 0; System Classification: Domestic Cold Water
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_pergamon
Text - Rsen_P_c01_definition: c01_cw; water connection: G 3/8
Plumbing - cw_position: 3; cw_connection_right: no; cw_connection_behind: no; cw_connection_left: yes
General - Rsen_C_content_creator: WISA
Mechanical - Flow - flush_volume: 0.26486 ft3
Constraints - Default Elevation: 0 mm; Host: Reference Plane; Elevation: 0 mm
Dimensions - Rsen_P_c01_diameter: 10 mm; Rsen_C_width: 453 mm; Rsen_C_height: 431 mm; flush pipe_height: 182 mm; connection-depth: 245 mm; Rsen_C_depth: 130 mm; connection-height: 365 mm
Identity Data - Rsen_C_code_STABU: 53.31; Rsen_C_code_gtin: 8711778074569; Rsen_C_description: WISA 1036 DF pergamon; Assembly Code: 4A(74.10); Assembly Description: algemeen (verzamelniveau); Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010864&ArtClassVersion=3; Rsen_C_code_ETIM: EC010864; Description: WISA 1036 DF pergamon; URL: www.wisa-sanitair.com/nl/8050423807; Type Comments: Low hanging cisterns; Rsen_C_type_comments: Low hanging cisterns; Rsen_C_code_SfB_table1: 74.10; Model: 1036; Rsen_C_model: 1036; Rsen_C_code_manufacturer_product: 8050423807; Rsen_C_code_manufacturer_gln: 8711778000001; Manufacturer: WISA; NLRS_C_revit_versie: 2014; Mark: 1719
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: pergamon_wisa_cistern wisa 300, RSen_74_PF_FB_surface mounted flushing reservoir wisa 300_wisa:pergamon_wisa_cistern wisa 300:3784828
In: Level 1
Type - ElementType: pergamon_wisa_cistern wisa 300; PredefinedType: CISTERN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_n6_PEXa_pergamon
Other - cw_length: 164 mm; cw_height: 373 mm; Schedule Level: Level: Level 1; cw_angle: 180 deg; calc_connection-depth: 240 mm; country_index: 1
Plumbing - cw_connection_behind: no; cw_connection_left: yes; cw_connection_right: no; cw_position: 3
Dimensions - flush pipe_height: 180 mm; connection-depth: 245 mm; connection-height: 365 mm; Rsen_C_depth: 134 mm; Rsen_C_height: 420 mm; Rsen_C_width: 338 mm; Rsen_P_c01_diameter: 10 mm
Constraints - Elevation: 0 mm; Host: Reference Plane; Default Elevation: 0 mm
Identity Data - Mark: 1702; Manufacturer: WISA; Rsen_C_code_manufacturer_product: 8050427714; NLRS_C_revit_versie: 2014; Rsen_C_code_STABU: 53.31; Assembly Code: 4A(74.22); Rsen_C_description: WISA 300 pergamon; Assembly Description: ingebouwde sanitaire voorzieningen; Rsen_C_code_manufacturer_gln: 8711778000001; Type Comments: Low hanging cisterns; Rsen_C_code_SfB_table1: 74.10; Rsen_C_code_gtin: 8711778099067; Rsen_C_type_comments: Laaghangend reservoir; Description: WISA 300 pergamon; Model: 300; Rsen_C_model: 300; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010864&ArtClassVersion=3; Rsen_C_code_ETIM: EC010864; URL: www.wisa-sanitair.com/nl/8050427714
Phasing - Phase Created: New Construction
Mechanical - System Classification: Domestic Cold Water; Rsen_P_c01_fixture units: 0; WFU: 0; CWFU: 0
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Text - Rsen_P_c01_definition: c01_cw; water connection: G 3/8
General - Rsen_C_content_creator: WISA
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_pergamon
Mechanical - Flow - flush_volume: 0.211888 ft3

# IfcFlowTerminal: pergamon_wisa_cistern wisa 336, RSen_74_PF_FB_surface mounted flushing reservoir wisa 336_wisa:pergamon_wisa_cistern wisa 336:3785034
In: Level 1
Type - ElementType: pergamon_wisa_cistern wisa 336; PredefinedType: CISTERN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_n6_PEXa_pergamon
Mechanical - System Classification: Domestic Cold Water; CWFU: 0; WFU: 0; Rsen_P_c01_fixture units: 0
Identity Data - Mark: 1705; Rsen_C_code_STABU: 53.31; Rsen_C_code_SfB_table1: 74.10; Rsen_C_code_gtin: 8711778115286; Type Comments: Low hanging cisterns; Rsen_C_type_comments: Low hanging cisterns; Rsen_C_code_manufacturer_product: 8050430714; Rsen_C_description: WISA 336 pergamon; Description: WISA 336 pergamon; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010864&ArtClassVersion=3; Model: 336; Assembly Code: 4A(74.22); Rsen_C_code_ETIM: EC010864; Manufacturer: WISA; NLRS_C_revit_versie: 2014; Assembly Description: ingebouwde sanitaire voorzieningen; URL: www.wisa-sanitair.com/nl/8050430714; Rsen_C_model: 336
Other - calc_connection-depth: 240 mm; cw_length: 164 mm; cw_height: 373 mm; Schedule Level: Level: Level 1; cw_angle: 180 deg; country_index: 1
Phasing - Phase Created: New Construction
Plumbing - cw_connection_left: yes; cw_connection_behind: no; cw_position: 3; cw_connection_right: no
Dimensions - connection-depth: 245 mm; Rsen_C_depth: 134 mm; flush pipe_height: 180 mm; connection-height: 365 mm; Rsen_C_width: 338 mm; Rsen_C_height: 420 mm; Rsen_P_c01_diameter: 10 mm
Constraints - Elevation: 0 mm; Host: Reference Plane; Default Elevation: 0 mm
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_pergamon
General - Rsen_C_content_creator: WISA
Text - water connection: G 3/8; Rsen_P_c01_definition: c01_cw
Mechanical - Flow - flush_volume: 0.211888 ft3

# IfcFlowTerminal: pergamon_wisa_cistern wisa 444, RSen_74_PF_FB_surface mounted flushing reservoir wisa 444_wisa:pergamon_wisa_cistern wisa 444:3785212
In: Level 1
Type - ElementType: pergamon_wisa_cistern wisa 444; PredefinedType: CISTERN; Classification: 4A(74.10) algemeen (verzamelniveau) (UniFormat); Material: RSen_n6_PEXa_pergamon
Plumbing - cw_connection_right: no; cw_connection_left: yes
Phasing - Phase Created: New Construction
Dimensions - flush pipe_height: 182 mm; connection-height: 365 mm; Rsen_C_depth: 289 mm; connection-depth: 245 mm; Rsen_C_width: 453 mm; Rsen_P_c01_diameter: 10 mm; Rsen_C_height: 342 mm
Constraints - Elevation: 0 mm; Host: Reference Plane; Default Elevation: 0 mm
Mechanical - System Classification: Domestic Cold Water; CWFU: 0; WFU: 0; Rsen_P_c01_fixture units: 0
Other - calc_connection-depth: 240 mm; calc_flush pipe_height: 182 mm; cw_angle: -45 deg; Schedule Level: Level: Level 1; country_index: 1
Identity Data - Mark: 1707; Rsen_C_code_SfB_table1: 74.10; Assembly Code: 4A(74.10); Type Comments: Low hanging cisterns; Rsen_C_code_ETIM: EC010864; Rsen_C_code_gtin: 8711778100237; Rsen_C_code_STABU: 53.31; URL: www.wisa-sanitair.com/nl/8050428514; Rsen_C_type_comments: Laaghangend reservoir; Assembly Description: algemeen (verzamelniveau); Model: 444; Rsen_C_code_manufacturer_product: 8050428514; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010864&ArtClassVersion=3; Rsen_C_model: 444; Manufacturer: WISA; Rsen_C_description: WISA 444 pergamon; Rsen_C_code_manufacturer_gln: 8711778000001; NLRS_C_revit_versie: 2014; Description: WISA 444 pergamon
Pset_ManufacturerTypeInformation - Manufacturer: WISA
General - Rsen_C_content_creator: WISA
Text - water connection: G 3/8; Rsen_P_c01_definition: c01_cw
Mechanical - Flow - flush_volume: 0.317832 ft3
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_pergamon

# IfcFlowTerminal: pergamon_wisa_cistern wisa 500, RSen_74_PF_FB_surface mounted flushing reservoir wisa 500_wisa:pergamon_wisa_cistern wisa 500:3785345
In: Level 1
Type - ElementType: pergamon_wisa_cistern wisa 500; PredefinedType: CISTERN; Classification: 4A(74.10) algemeen (verzamelniveau) (UniFormat); Material: RSen_n6_PEXa_pergamon
Other - cw_length: 256 mm; Schedule Level: Level: Level 1; calc_connection-depth: 227 mm; cw_height: 325 mm; cw_angle: 180 deg; country_index: 1
Mechanical - System Classification: Domestic Cold Water; Rsen_P_c01_fixture units: 0; CWFU: 0; WFU: 0
Identity Data - Mark: 1709; Type Comments: Low hanging cisterns; Assembly Code: 4A(74.10); Rsen_C_code_manufacturer_product: 8050422697; Rsen_C_code_STABU: 53.31; Rsen_C_code_SfB_table1: 74.10; Model: 500; Description: WISA 500 beige; Rsen_C_code_gtin: 8711778033061; Rsen_C_description: WISA 500 beige; URL: www.wisa-sanitair.com/nl/8050422697; Manufacturer: WISA; Assembly Description: algemeen (verzamelniveau); NLRS_C_revit_versie: 2014; Rsen_C_type_comments: Low hanging cisterns; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_code_ETIM: EC010864; Rsen_C_model: 500; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010864&ArtClassVersion=3
Dimensions - connection-height: 365 mm; connection-depth: 245 mm; flush pipe_height: 182 mm; Rsen_C_depth: 106 mm; Rsen_C_height: 355 mm; Rsen_C_width: 512 mm; Rsen_P_c01_diameter: 10 mm
Phasing - Phase Created: New Construction
Plumbing - cw_connection_left: yes; cw_connection_behind: no; cw_position: 3; cw_connection_right: no
Constraints - Host: Reference Plane; Elevation: 0 mm; Default Elevation: 0 mm
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Text - water connection: G 3/8; Rsen_P_c01_definition: c01_cw
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_pergamon
Mechanical - Flow - flush_volume: 0.317832 ft3
General - Rsen_C_content_creator: WISA

# IfcFlowTerminal: pergamon_wisa_cistern wisa 790, RSen_74_PF_FB_surface mounted flushing reservoir wisa 790_wisa:pergamon_wisa_cistern wisa 790:3785539
In: Level 1
Type - ElementType: pergamon_wisa_cistern wisa 790; PredefinedType: CISTERN; Classification: 4A(74.10) algemeen (verzamelniveau) (UniFormat); Material: RSen_n6_PEXa_pergamon
Other - cw_height: 330 mm; Schedule Level: Level: Level 1; calc_connection-depth: 237 mm; cw_angle: 180 deg; cw_length: 250 mm; country_index: 1
Constraints - Host: Reference Plane; Elevation: 0 mm; Default Elevation: 0 mm
Identity Data - Mark: 1712; Assembly Description: algemeen (verzamelniveau); Description: WISA 790 pergamon; Rsen_C_code_ETIM: EC010864; Rsen_C_description: WISA 790 pergamon; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010864&ArtClassVersion=3; Type Comments: Low hanging cisterns; Manufacturer: WISA; Assembly Code: 4A(74.10); Model: 790; Rsen_C_type_comments: Low hanging cisterns; Rsen_C_code_STABU: 53.31; URL: www.wisa-sanitair.com/nl/8050426007; Rsen_C_code_gtin: 8711778032736; Rsen_C_model: 790; Rsen_C_code_SfB_table1: 74.10; Rsen_C_code_manufacturer_product: 8050426007; NLRS_C_revit_versie: 2014; Rsen_C_code_manufacturer_gln: 8711778000001
Dimensions - connection-depth: 245 mm; flush pipe_height: 182 mm; Rsen_C_depth: 128 mm; connection-height: 365 mm; Rsen_C_height: 401 mm; Rsen_C_width: 510 mm; Rsen_P_c01_diameter: 10 mm
Plumbing - cw_connection_behind: no; cw_connection_left: yes; cw_position: 3; cw_connection_right: no
Mechanical - System Classification: Domestic Cold Water; Rsen_P_c01_fixture units: 0; CWFU: 0; WFU: 0
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Text - water connection: G 3/8; Rsen_P_c01_definition: c01_cw
General - Rsen_C_content_creator: WISA
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_pergamon
Mechanical - Flow - flush_volume: 0.317832 ft3

# IfcFlowTerminal: white_wisa_cistern (2)
In: Level 1
Type - ElementType: white_wisa_cistern; PredefinedType: CISTERN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_n6_PEXa_white
General - Rsen_C_content_creator: WISA
Constraints - Default Elevation: 0 mm; Host: Reference Plane
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_white
Mechanical - CWFU: 0; WFU: 0
Identity Data - Rsen_C_code_STABU: 53.31; Rsen_C_code_SfB_table1: 74.10; Assembly Description: ingebouwde sanitaire voorzieningen; NLRS_C_revit_versie: 2014; Rsen_C_code_manufacturer_gln: 8711778000001; Manufacturer: WISA; Assembly Code: 4A(74.22)
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Name | Rsen_C_height (mm) | Rsen_C_code_ETIM_url | Rsen_C_model = Model | Rsen_C_code_gtin | Type Comments | Rsen_C_type_comments | Rsen_C_code_ETIM | Description = Rsen_C_description | URL | Rsen_C_code_manufacturer_product | Mark
RSen_74_PF_FB_surface mounted flushing reservoir wisa 900_wisa:white_wisa_cistern:3786063 | 360 | http://working.etim-international.com/class_view.aspx?ArtClassID=EC010864&ArtClassVersion=3 | 900 | 8711778094840 | Low hanging cisterns | Laaghangend reservoir | EC010864 | WISA 900 | www.wisa-sanitair.com/nl/8050421990 | 8050421990 | 1720 | Plumbing - cw_connection_right: no; cw_position: 0; cw_connection_left: no; cw_connection_behind: yes; Text - water connection: G 3/8; Rsen_P_c01_definition: c01_cw; Mechanical - Flow - flush_volume: 0.317832 ft3; Dimensions - Rsen_P_c01_diameter: 10 mm; Rsen_C_width: 420 mm; connection-depth: 245 mm; flush pipe_height: 182 mm; Rsen_C_depth: 166 mm; connection-height: 365 mm; Mechanical - Rsen_P_c01_fixture units: 0; System Classification: Domestic Cold Water; Constraints - Elevation: 0 mm; Other - cw_angle: 90 deg; cw_length: 45 mm; calc_connection-depth: 245 mm; Schedule Level: Level: Level 1; cw_height: 342 mm
RSen_74_PF_FB_high flush pipe wisa 285_wisa:white_wisa_cistern:3786272 | 1550 | http://working.etim-international.com/class_view.aspx?ArtClassID=EC010141&ArtClassVersion=4 | 285 | 8711778004061 | High flush pipe | High flush pipe | EC010141 | Flush pipe WISA 285 | www.wisa-sanitair.com/nl/1409986000 | 8050421550 | 1724 | Constraints - Moves With Nearby Elements: no

# IfcFlowTerminal: white_wisa_cistern (2)
In: Level 1
Type - ElementType: white_wisa_cistern; PredefinedType: CISTERN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_n6_PEXa_white, RSen_h4_aluminium_bright chrome
General - Rsen_C_content_creator: WISA
Dimensions - Rsen_C_height: 415 mm; Rsen_P_c01_diameter: 10 mm; Rsen_C_width: 404 mm; Rsen_C_depth: 162 mm
Constraints - Default Elevation: 0 mm; Elevation: 0 mm; Host: Reference Plane
Plumbing - cw_position: 2; cw_connection_right: yes; cw_connection_left: no; cw_connection_behind: no
Mechanical - WFU: 0; Rsen_P_c01_fixture units: 0; CWFU: 0; System Classification: Domestic Cold Water
Text - Rsen_P_c01_definition: c01_cw; water connection: G 3/8
Materials and Finishes - Rsen_C_material_01: RSen_h4_aluminium_bright chrome; Rsen_C_material: RSen_n6_PEXa_white
Identity Data - Rsen_C_model: 800; Assembly Code: 4A(74.22); Model: 800; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_type_comments: Close coupled cistern; NLRS_C_revit_versie: 2014; Rsen_C_code_ETIM: EC010864; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010864&ArtClassVersion=3; Rsen_C_code_STABU: 53.31; Assembly Description: ingebouwde sanitaire voorzieningen; Manufacturer: WISA; Rsen_C_code_SfB_table1: 74.10; Type Comments: Close coupled cistern
Phasing - Phase Created: New Construction
Other - cw_angle: 0 deg; cw_height: 328 mm; cw_length: 202 mm; Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Name | flush_volume (ft3) | Rsen_C_code_gtin | URL | Rsen_C_code_manufacturer_product | Description = Rsen_C_description | Mark
RSen_74_PF_FB_surface mounted flushing reservoir wisa 800_wisa:white_wisa_cistern:3786169 | 0.317832 | 8711778058590 | www.wisa-sanitair.com/nl/8050425760 | 8050425760 | WISA 800 6-9 liter | 1721
RSen_74_PF_FB_surface mounted flushing reservoir wisa 800 df_wisa:white_wisa_cistern:3786222 | 0.211888 | 8711778072596 | www.wisa-sanitair.com/nl/8050425790 | 8050425790 | WISA 800 3/6 liter DF | 1722

# IfcFlowTerminal: white_wisa_cistern wisa 1000, RSen_74_PF_FB_surface mounted flushing reservoir wisa 1000_wisa:white_wisa_cistern wisa 1000:3785825
In: Level 1
Type - ElementType: white_wisa_cistern wisa 1000; PredefinedType: CISTERN; Classification: 4A(74.10) algemeen (verzamelniveau) (UniFormat); Material: RSen_n6_PEXa_white
Mechanical - Flow - flush_volume: 0.317832 ft3
Other - country_index: 0; Schedule Level: Level: Level 1; calc_connection-depth: 240 mm; cw_angle: 90 deg; cw_height: 321 mm; cw_length: 51 mm
Constraints - Default Elevation: 0 mm; Host: Reference Plane; Elevation: 0 mm
Plumbing - cw_connection_right: no; cw_position: 0; cw_connection_behind: yes; cw_connection_left: no
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_white
Dimensions - Rsen_P_c01_diameter: 10 mm; Rsen_C_height: 431 mm; Rsen_C_width: 453 mm; connection-height: 365 mm; connection-depth: 245 mm; Rsen_C_depth: 130 mm; flush pipe_height: 182 mm
Mechanical - System Classification: Domestic Cold Water; Rsen_P_c01_fixture units: 0; WFU: 0; CWFU: 0
Phasing - Phase Created: New Construction
Identity Data - Mark: 1715; Model: 1000; Rsen_C_model: 1000; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010864&ArtClassVersion=3; Rsen_C_code_SfB_table1: 74.10; Rsen_C_code_ETIM: EC010864; Rsen_C_description: WISA 1000 white; Manufacturer: WISA; Rsen_C_code_STABU: 53.31; Rsen_C_type_comments: Laaghangend reservoir; NLRS_C_revit_versie: 2014; Rsen_C_code_gtin: 8711778015548; URL: www.wisa-sanitair.com/nl/8050424000; Rsen_C_code_manufacturer_product: 805042400; Assembly Code: 4A(74.10); Rsen_C_code_manufacturer_gln: 8711778000001; Type Comments: Low hanging cisterns; Description: WISA 1000 white; Assembly Description: algemeen (verzamelniveau)
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Text - Rsen_P_c01_definition: c01_cw; water connection: G 3/8
General - Rsen_C_content_creator: WISA

# IfcFlowTerminal: white_wisa_cistern wisa 1000 with cover lock, RSen_74_PF_FB_surface mounted flushing reservoir with cover lock_wisa:white_wisa_cistern wisa 1000 with cover lock:3785905
In: Level 1
Type - ElementType: white_wisa_cistern wisa 1000 with cover lock; PredefinedType: CISTERN; Classification: 4A(74.10) algemeen (verzamelniveau) (UniFormat); Material: RSen_n6_PEXa_white
Plumbing - cw_connection_right: no; cw_position: 0; cw_connection_left: no; cw_connection_behind: yes
Constraints - Default Elevation: 0 mm; Elevation: 0 mm; Host: Reference Plane
Text - Rsen_P_c01_definition: c01_cw; water connection: G 3/8
General - Rsen_C_content_creator: WISA
Mechanical - Flow - flush_volume: 0.317832 ft3
Dimensions - Rsen_P_c01_diameter: 10 mm; Rsen_C_width: 453 mm; Rsen_C_height: 431 mm; flush pipe_height: 182 mm; connection-height: 365 mm; Rsen_C_depth: 130 mm; connection-depth: 245 mm
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_white
Identity Data - Rsen_C_code_ETIM: EC010864; Rsen_C_code_SfB_table1: 74.10; Rsen_C_code_gtin: 8711778049338; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010864&ArtClassVersion=3; Type Comments: Low hanging cisterns; Rsen_C_description: WISA 1000 with cover lock; Assembly Description: algemeen (verzamelniveau); Manufacturer: WISA; URL: www.wisa-sanitair.com/nl/8050424060; Assembly Code: 4A(74.10); Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_code_STABU: 53.31; Model: 1000; Rsen_C_code_manufacturer_product: 8050424060; Rsen_C_model: 1000; Rsen_C_type_comments: Laaghangend reservoir; NLRS_C_revit_versie: 2014; Description: WISA 1000 with cover lock; Mark: 1717
Mechanical - WFU: 0; Rsen_P_c01_fixture units: 0; CWFU: 0; System Classification: Domestic Cold Water
Other - cw_height: 321 mm; cw_angle: 90 deg; cw_length: 51 mm; Schedule Level: Level: Level 1; calc_connection-depth: 240 mm
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: white_wisa_cistern wisa 1036, RSen_74_PF_FB_surface mounted flushing reservoir wisa 1036_wisa:white_wisa_cistern wisa 1036:3785967
In: Level 1
Type - ElementType: white_wisa_cistern wisa 1036; PredefinedType: CISTERN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_n6_PEXa_white
Mechanical - Flow - flush_volume: 0.26486 ft3
General - Rsen_C_content_creator: WISA
Constraints - Default Elevation: 0 mm; Elevation: 0 mm; Host: Reference Plane
Dimensions - Rsen_C_width: 453 mm; Rsen_P_c01_diameter: 10 mm; Rsen_C_height: 431 mm; connection-height: 365 mm; Rsen_C_depth: 130 mm; connection-depth: 245 mm; flush pipe_height: 182 mm
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_white
Text - Rsen_P_c01_definition: c01_cw; water connection: G 3/8
Mechanical - CWFU: 0; WFU: 0; Rsen_P_c01_fixture units: 0; System Classification: Domestic Cold Water
Plumbing - cw_position: 0; cw_connection_right: no; cw_connection_left: no; cw_connection_behind: yes
Other - country_index: 0; cw_angle: 90 deg; cw_length: 51 mm; Schedule Level: Level: Level 1; calc_connection-depth: 240 mm; cw_height: 321 mm
Identity Data - Rsen_C_code_manufacturer_product: 8050423800; Assembly Description: ingebouwde sanitaire voorzieningen; Rsen_C_type_comments: Low hanging cisterns; Assembly Code: 4A(74.22); NLRS_C_revit_versie: 2014; Model: 1036; Manufacturer: WISA; Rsen_C_code_manufacturer_gln: 8711778000001; URL: www.wisa-sanitair.com/nl/8050423800; Rsen_C_code_SfB_table1: 74.10; Description: WISA 1036 DF white; Rsen_C_model: 1036; Rsen_C_code_gtin: 8711778070622; Type Comments: Low hanging cisterns; Rsen_C_description: WISA 1036 DF white; Rsen_C_code_ETIM: EC010864; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010864&ArtClassVersion=3; Rsen_C_code_STABU: 53.31; Mark: 1718
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: white_wisa_cistern wisa 285, RSen_74_PF_FB_high hanging cistern wisa 285_wisa:white_wisa_cistern wisa 285:3786270
In: Level 1
Type - ElementType: white_wisa_cistern wisa 285; PredefinedType: CISTERN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_n6_PEXa_white
Text - Rsen_P_c01_definition: c01_cw; water connection: G 3/8
General - Rsen_C_content_creator: WISA
Constraints - Default Elevation: 0 mm; Host: Reference Plane; Elevation: 0 mm
Dimensions - Rsen_P_c01_diameter: 10 mm; Rsen_C_width: 420 mm; Rsen_C_height: 315 mm; Rsen_C_depth: 166 mm; connection-depth: 0 mm
Mechanical - Rsen_P_c01_fixture units: 0; WFU: 0; CWFU: 0; System Classification: Domestic Cold Water
Mechanical - Flow - flush_volume: 0.317832 ft3
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_white
Identity Data - Description: WISA 285 without flush pipe; Rsen_C_code_ETIM: EC010864; Rsen_C_type_comments: Hoogreservoir; URL: www.wisa-sanitair.com/nl/8050421500; Assembly Description: ingebouwde sanitaire voorzieningen; Rsen_C_code_SfB_table1: 74.10; Manufacturer: WISA; NLRS_C_revit_versie: 2014; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010864&ArtClassVersion=3; Rsen_C_code_manufacturer_product: 8050421500; Rsen_C_code_gtin: 8711778013933; Rsen_C_description: WISA 285 without flush pipe; Rsen_C_code_STABU: 53.31; Assembly Code: 4A(74.22); Rsen_C_model: 285; Type Comments: High hanging cistern; Model: 285; Rsen_C_code_manufacturer_gln: 8711778000001; Mark: 1723
Other - calc_connection-depth: 140 mm; Schedule Level: Level: Level 1; cw_angle: 0 deg
Phasing - Phase Created: New Construction
Plumbing - cw_right: yes; flush pipe: yes; cw_left: no
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: white_wisa_cistern wisa 300, RSen_74_PF_FB_surface mounted flushing reservoir wisa 300_wisa:white_wisa_cistern wisa 300:3784736
In: Level 1
Type - ElementType: white_wisa_cistern wisa 300; PredefinedType: CISTERN; Classification: 4A(74.10) algemeen (verzamelniveau) (UniFormat); Material: RSen_n6_PEXa_white
Constraints - Elevation: 0 mm; Host: Reference Plane; Default Elevation: 0 mm
Phasing - Phase Created: New Construction
Mechanical - System Classification: Domestic Cold Water; CWFU: 0; WFU: 0; Rsen_P_c01_fixture units: 0
Plumbing - cw_connection_behind: no; cw_connection_left: no; cw_position: 2; cw_connection_right: yes
Identity Data - Mark: 1701; Assembly Description: algemeen (verzamelniveau); Rsen_C_model: 300; NLRS_C_revit_versie: 2014; URL: www.wisa-sanitair.com/nl/8050427701; Assembly Code: 4A(74.10); Rsen_C_code_gtin: 8711778096462; Rsen_C_code_SfB_table1: 74.10; Description: WISA 300 white; Rsen_C_description: WISA 300 white; Rsen_C_type_comments: Laaghangend reservoir; Manufacturer: WISA; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010864&ArtClassVersion=3; Rsen_C_code_manufacturer_product: 8050427701; Rsen_C_code_ETIM: EC010864; Rsen_C_code_manufacturer_gln: 8711778000001; Model: 300; Rsen_C_code_STABU: 53.31; Type Comments: Low hanging cisterns
Dimensions - connection-depth: 245 mm; connection-height: 365 mm; flush pipe_height: 180 mm; Rsen_C_depth: 134 mm; Rsen_P_c01_diameter: 10 mm; Rsen_C_height: 420 mm; Rsen_C_width: 338 mm
Other - cw_angle: 0 deg; cw_height: 373 mm; calc_connection-depth: 240 mm; cw_length: 164 mm; Schedule Level: Level: Level 1; country_index: 0
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Text - water connection: G 3/8; Rsen_P_c01_definition: c01_cw
General - Rsen_C_content_creator: WISA
Mechanical - Flow - flush_volume: 0.211888 ft3
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_white

# IfcFlowTerminal: white_wisa_cistern wisa 300 pneumatic, RSen_74_PF_FB_surface mounted flushing reservoir wisa 300 pneumatic_wisa:white_wisa_cistern wisa 300 pneumatic:3784881
In: Level 1
Type - ElementType: white_wisa_cistern wisa 300 pneumatic; PredefinedType: CISTERN; Classification: 4A(74.10) algemeen (verzamelniveau) (UniFormat); Material: RSen_n6_PEXa_white
Constraints - Elevation: 0 mm; Host: Reference Plane; Default Elevation: 0 mm
Other - cw_angle: 0 deg; Schedule Level: Level: Level 1; calc_connection-depth: 240 mm; cw_length: 164 mm; cw_height: 373 mm
Phasing - Phase Created: New Construction
Dimensions - Rsen_C_depth: 134 mm; flush pipe_height: 180 mm; connection-depth: 245 mm; connection-height: 365 mm; Rsen_C_height: 420 mm; Rsen_P_c01_diameter: 10 mm; Rsen_C_width: 338 mm
Mechanical - System Classification: Domestic Cold Water; Rsen_P_c01_fixture units: 0; WFU: 0; CWFU: 0
Identity Data - Mark: 1703; Rsen_C_description: WISA 300 pneumatisch (zonder knop en spoelbocht); Assembly Description: algemeen (verzamelniveau); Model: 300; Rsen_C_model: 300; NLRS_C_revit_versie: 2014; Manufacturer: WISA; Rsen_C_code_gtin: 8711778105782; Description: WISA 300 pneumatic (without button and flush pipe); Type Comments: Low hanging cisterns; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_code_manufacturer_product: 8050427790; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010864&ArtClassVersion=3; Rsen_C_code_STABU: 53.31; Rsen_C_type_comments: Low hanging cisterns; Rsen_C_code_ETIM: EC010864; URL: www.wisa-sanitair.com/nl/8050427790; Rsen_C_code_SfB_table1: 74.10; Assembly Code: 4A(74.10)
Plumbing - cw_connection_behind: no; cw_connection_left: no; cw_connection_right: yes; cw_position: 2
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_white
Mechanical - Flow - flush_volume: 0.211888 ft3
General - Rsen_C_content_creator: WISA
Text - water connection: G 3/8; Rsen_P_c01_definition: c01_cw

# IfcFlowTerminal: white_wisa_cistern wisa 336, RSen_74_PF_FB_surface mounted flushing reservoir wisa 336_wisa:white_wisa_cistern wisa 336:3784983
In: Level 1
Type - ElementType: white_wisa_cistern wisa 336; PredefinedType: CISTERN; Classification: 4A(74.10) algemeen (verzamelniveau) (UniFormat); Material: RSen_n6_PEXa_white
Other - calc_connection-depth: 240 mm; Schedule Level: Level: Level 1; cw_angle: 0 deg; cw_height: 373 mm; cw_length: 164 mm; country_index: 0
Identity Data - Mark: 1704; Assembly Description: algemeen (verzamelniveau); Rsen_C_description: WISA 336 white; Rsen_C_model: 336; Rsen_C_type_comments: Low hanging cisterns; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010864&ArtClassVersion=3; Assembly Code: 4A(74.10); Manufacturer: WISA; Model: 336; NLRS_C_revit_versie: 2014; Rsen_C_code_manufacturer_product: 8050430701; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_code_gtin: 8711778115279; Rsen_C_code_STABU: 53.31; Description: WISA 336 white; Rsen_C_code_SfB_table1: 74.10; Type Comments: Low hanging cisterns; URL: www.wisa-sanitair.com/nl/8050430701; Rsen_C_code_ETIM: EC010864
Mechanical - System Classification: Domestic Cold Water; WFU: 0; CWFU: 0; Rsen_P_c01_fixture units: 0
Dimensions - connection-height: 365 mm; flush pipe_height: 180 mm; Rsen_C_depth: 134 mm; connection-depth: 245 mm; Rsen_C_height: 420 mm; Rsen_P_c01_diameter: 10 mm; Rsen_C_width: 338 mm
Plumbing - cw_connection_behind: no; cw_connection_left: no; cw_position: 2; cw_connection_right: yes
Constraints - Host: Reference Plane; Elevation: 0 mm; Default Elevation: 0 mm
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Text - water connection: G 3/8; Rsen_P_c01_definition: c01_cw
Mechanical - Flow - flush_volume: 0.211888 ft3
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_white
General - Rsen_C_content_creator: WISA

# IfcFlowTerminal: white_wisa_cistern wisa 444, RSen_74_PF_FB_surface mounted flushing reservoir wisa 444_wisa:white_wisa_cistern wisa 444:3785162
In: Level 1
Type - ElementType: white_wisa_cistern wisa 444; PredefinedType: CISTERN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_n6_PEXa_white
Constraints - Host: Reference Plane; Elevation: 0 mm; Default Elevation: 0 mm
Mechanical - System Classification: Domestic Cold Water; Rsen_P_c01_fixture units: 0; CWFU: 0; WFU: 0
Dimensions - connection-height: 365 mm; connection-depth: 245 mm; Rsen_C_depth: 289 mm; flush pipe_height: 182 mm; Rsen_C_height: 342 mm; Rsen_P_c01_diameter: 10 mm; Rsen_C_width: 453 mm
Identity Data - Mark: 1706; URL: www.wisa-sanitair.com/nl/8050428501; Assembly Description: ingebouwde sanitaire voorzieningen; Type Comments: Low hanging cisterns; Rsen_C_code_STABU: 53.31; Manufacturer: WISA; Description: WISA 444 white; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010864&ArtClassVersion=3; Assembly Code: 4A(74.22); Rsen_C_description: WISA 444 white; Model: 444; NLRS_C_revit_versie: 2014; Rsen_C_type_comments: Laaghangend reservoir; Rsen_C_code_SfB_table1: 74.10; Rsen_C_code_ETIM: EC010864; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_code_gtin: 8711778100220; Rsen_C_model: 444; Rsen_C_code_manufacturer_product: 8050428501
Other - calc_connection-depth: 240 mm; Schedule Level: Level: Level 1; cw_angle: 45 deg; calc_flush pipe_height: 182 mm; country_index: 0
Plumbing - cw_connection_left: no; cw_connection_right: yes
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: WISA
General - Rsen_C_content_creator: WISA
Text - water connection: G 3/8; Rsen_P_c01_definition: c01_cw
Mechanical - Flow - flush_volume: 0.317832 ft3
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_white

# IfcFlowTerminal: white_wisa_cistern wisa 500, RSen_74_PF_FB_surface mounted flushing reservoir wisa 500_wisa:white_wisa_cistern wisa 500:3785292
In: Level 1
Type - ElementType: white_wisa_cistern wisa 500; PredefinedType: CISTERN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_n6_PEXa_white
Constraints - Elevation: 0 mm; Host: Reference Plane; Default Elevation: 0 mm
Dimensions - connection-depth: 245 mm; flush pipe_height: 182 mm; Rsen_C_depth: 106 mm; connection-height: 365 mm; Rsen_C_width: 512 mm; Rsen_C_height: 355 mm; Rsen_P_c01_diameter: 10 mm
Mechanical - System Classification: Domestic Cold Water; WFU: 0; Rsen_P_c01_fixture units: 0; CWFU: 0
Identity Data - Mark: 1708; Assembly Code: 4A(74.22); Rsen_C_code_ETIM: EC010864; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010864&ArtClassVersion=3; Model: 500; Rsen_C_code_manufacturer_product: 8050422670; NLRS_C_revit_versie: 2014; Assembly Description: ingebouwde sanitaire voorzieningen; Manufacturer: WISA; Rsen_C_model: 500; Rsen_C_type_comments: Low hanging cisterns; Type Comments: Low hanging cisterns; Rsen_C_code_SfB_table1: 74.10; URL: www.wisa-sanitair.com/nl/8050422670; Rsen_C_description: WISA 500 wit; Description: WISA 500 white; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_code_STABU: 53.31; Rsen_C_code_gtin: 8711778014565
Phasing - Phase Created: New Construction
Plumbing - cw_connection_left: no; cw_connection_behind: yes; cw_position: 0; cw_connection_right: no
Other - calc_connection-depth: 227 mm; cw_height: 360 mm; cw_length: 42 mm; Schedule Level: Level: Level 1; cw_angle: 90 deg; country_index: 0
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Text - water connection: G 3/8; Rsen_P_c01_definition: c01_cw
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_white
Mechanical - Flow - flush_volume: 0.317832 ft3
General - Rsen_C_content_creator: WISA

# IfcFlowTerminal: white_wisa_cistern wisa 790, RSen_74_PF_FB_surface mounted flushing reservoir wisa 790_wisa:white_wisa_cistern wisa 790:3785475
In: Level 1
Type - ElementType: white_wisa_cistern wisa 790; PredefinedType: CISTERN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_n6_PEXa_white
Other - Schedule Level: Level: Level 1; cw_angle: 90 deg; cw_height: 360 mm; calc_connection-depth: 237 mm; cw_length: 50 mm; country_index: 0
Mechanical - System Classification: Domestic Cold Water; WFU: 0; Rsen_P_c01_fixture units: 0; CWFU: 0
Phasing - Phase Created: New Construction
Identity Data - Mark: 1711; Rsen_C_code_manufacturer_product: 8050426000; Assembly Description: ingebouwde sanitaire voorzieningen; Assembly Code: 4A(74.22); URL: www.wisa-sanitair.com/nl/8050426000; Rsen_C_code_manufacturer_gln: 8711778000001; Type Comments: Low hanging cisterns; Rsen_C_code_gtin: 8711778031821; Rsen_C_code_ETIM: EC010864; Rsen_C_description: WISA 790 wit; Description: WISA 790 white; Rsen_C_code_STABU: 53.31; Rsen_C_code_SfB_table1: 74.10; Rsen_C_model: 790; NLRS_C_revit_versie: 2014; Rsen_C_type_comments: Low hanging cisterns; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010864&ArtClassVersion=3; Model: 790; Manufacturer: WISA
Plumbing - cw_connection_behind: yes; cw_connection_left: no; cw_connection_right: no; cw_position: 0
Dimensions - flush pipe_height: 182 mm; Rsen_C_depth: 128 mm; connection-depth: 245 mm; connection-height: 365 mm; Rsen_P_c01_diameter: 10 mm; Rsen_C_height: 401 mm; Rsen_C_width: 510 mm
Constraints - Host: Reference Plane; Elevation: 0 mm; Default Elevation: 0 mm
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Mechanical - Flow - flush_volume: 0.317832 ft3
General - Rsen_C_content_creator: WISA
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_white
Text - water connection: G 3/8; Rsen_P_c01_definition: c01_cw

# IfcFlowTerminal: white_wisa_cistern wisa 790 with cover lock, RSen_74_PF_FB_surface mounted flushing reservoir wisa 790 with cover lock_wisa:white_wisa_cistern wisa 790 with cover lock:3785661
In: Level 1
Type - ElementType: white_wisa_cistern wisa 790 with cover lock; PredefinedType: CISTERN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_n6_PEXa_white
Phasing - Phase Created: New Construction
Other - Schedule Level: Level: Level 1; calc_connection-depth: 237 mm; cw_length: 50 mm; cw_angle: 90 deg; cw_height: 360 mm
Dimensions - Rsen_C_depth: 128 mm; flush pipe_height: 182 mm; connection-depth: 245 mm; connection-height: 365 mm; Rsen_C_width: 510 mm; Rsen_P_c01_diameter: 10 mm; Rsen_C_height: 401 mm
Identity Data - Mark: 1714; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010864&ArtClassVersion=3; Description: WISA 790 with cover lock; URL: www.wisa-sanitair.com/nl/8050426050; Assembly Description: ingebouwde sanitaire voorzieningen; Rsen_C_code_ETIM: EC010864; Manufacturer: WISA; Rsen_C_code_STABU: 53.31; Rsen_C_code_SfB_table1: 74.10; Rsen_C_type_comments: Low hanging cisterns; Rsen_C_code_manufacturer_gln: 8711778000001; Type Comments: Low hanging cisterns; Rsen_C_description: WISA 790 with cover lock; Rsen_C_code_gtin: 8711778031869; Assembly Code: 4A(74.22); NLRS_C_revit_versie: 2014; Rsen_C_model: 790; Model: 790; Rsen_C_code_manufacturer_product: 8050426050
Constraints - Host: Reference Plane; Elevation: 0 mm; Default Elevation: 0 mm
Mechanical - System Classification: Domestic Cold Water; CWFU: 0; Rsen_P_c01_fixture units: 0; WFU: 0
Plumbing - cw_connection_left: no; cw_connection_behind: yes; cw_connection_right: no; cw_position: 0
Pset_ManufacturerTypeInformation - Manufacturer: WISA
General - Rsen_C_content_creator: WISA
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_white
Mechanical - Flow - flush_volume: 0.317832 ft3
Text - water connection: G 3/8; Rsen_P_c01_definition: c01_cw

# IfcFlowTerminal: white_wisa_high flush pipe wisa 285, RSen_74_PF_FB_high flush pipe wisa 285_wisa:white_wisa_high flush pipe wisa 285:3786343
In: Level 1
Type - ElementType: white_wisa_high flush pipe wisa 285; PredefinedType: CISTERN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_n6_PEXa_white
Materials and Finishes - Rsen_C_material: RSen_n6_PEXa_white
Dimensions - Rsen_C_height: 1550 mm
Constraints - Default Elevation: 0 mm; Host: Reference Plane; Elevation: 0 mm
General - Rsen_C_content_creator: WISA
Identity Data - Rsen_C_type_comments: High flush pipe; Rsen_C_code_STABU: 53.31; Type Comments: High flush pipe; Description: Flush pipe WISA 285; Assembly Description: ingebouwde sanitaire voorzieningen; Rsen_C_code_gtin: 8711778004061; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010141&ArtClassVersion=4; Rsen_C_code_manufacturer_product: 8050421550; Manufacturer: WISA; Model: 285; Assembly Code: 4A(74.22); URL: www.wisa-sanitair.com/nl/1409986000; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_model: 285; Rsen_C_code_SfB_table1: 74.10; Rsen_C_description: Flush pipe WISA 285; NLRS_C_revit_versie: 2014; Rsen_C_code_ETIM: EC010141; Mark: 1725
Mechanical - WFU: 0; CWFU: 0
Phasing - Phase Created: New Construction
Other - Schedule Level: Level: Level 1
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcMember: 74_WISA_logo, 74_WISA_logo:74_WISA_logo:2591814
In: Level 1
Type - ElementType: 74_WISA_logo; Classification:  (UniFormat); Material: WISA blauw
Constraints - Host: Level : Level 1; Offset: 0 mm; Moves With Nearby Elements: no; Level: Level: Level 1
Phasing - Phase Created: New Construction
Dimensions - Volume: 4.01625 ft3
Pset_MemberCommon - Reference: 74_WISA_logo; LoadBearing: yes; IsExternal: no; Span: 50 mm; Slope: 0 deg
